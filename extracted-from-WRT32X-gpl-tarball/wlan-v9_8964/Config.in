## extracted-from-WRT32X-gpl-tarball/wlan-v9_8964/Config.in
```kconfig
config MARVELL_WLAN_SOURCES
	bool "Compile the driver from source"
	depends on PACKAGE_kmod-wlan-v9_8964
	default n
```
